# Keil uVision project ADC_DMA_MULTI_Heart.uvprojx, settings and files
target Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC_DMA_MULTI_Heart
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, ARM_MATH_CM4
  c include: .\Source;.\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./Source/: main.cpp Main_Thread.cpp
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Inc/: stm32f4xx_it.h
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Src/: stm32f4xx_it.c adc.c dma.c gpio.c spi.c tim.c usart.c
  group Include
    ./Include/: Main_Thread.h
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.80.0, eObject Framework:Core 0.11.0, Compiler:I/O:File 1.2.0, File System:CORE 6.7.0, File System:Drive:Memory Card 6.7.0, CMSIS Driver:SPI 2.9, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:STM32Cube HAL:UART 1.6.0, Device:STM32Cube HAL:USART 1.6.0, Device:Startup 2.6.0
